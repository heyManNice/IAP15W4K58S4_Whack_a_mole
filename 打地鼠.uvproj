# Keil uVision project 打地鼠.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 打地鼠 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\head
  group src
    ./src/: buzzer.c display.c framework.c game.c keyboard.c random.c task.c
  group head
    ./head/: buzzer.h display.h framework.h game.h keyboard.h pin.h random.h
